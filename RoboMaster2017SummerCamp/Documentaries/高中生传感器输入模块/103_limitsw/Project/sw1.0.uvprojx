# Keil uVision project sw1.0.uvprojx, settings and files
target LMSW (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sw1.0
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\lib;..\CMSIS;..\user;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c
  group bsp
    ../bsp/: bsp.c limitsw.c delay.c led.c can.c
  group lib
    ../user/: stm32f10x_it.c
    ../lib/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c
  group CMISIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 5.0.1
